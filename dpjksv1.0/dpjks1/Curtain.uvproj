# Keil uVision project Curtain.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Curtain +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware\motor;.\system\delay;.\hardware\temperature;.\hardware\lumination;.\hardware\usart;.\hardware\display_lcd12864;.\hardware\display_lcd1602;.\system\control;.\system\iic;.\system\timer;.\hardware\clock;.\hardware\csb
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./hardware/motor/: motordriver.c
    ./hardware/clock/: DS1302.c
    ./hardware/display_lcd1602/: lcd1602.c
    ./hardware/lumination/: lumination.c
    ./system/iic/: i2c.c
    ./system/delay/: delay.c
    ./hardware/temperature/: 18b20.c
    ./hardware/usart/: bt.c
    ./system/control/: control.c
    ./hardware/display_lcd12864/: lcd12864.c
    ./system/timer/: Tim0.c
    ./hardware/csb/: csb.c

# Keil uVision project Curtain.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Curtain
  c flags: Optimize=8 SizeSpeed=1
  c include: .\hardware\motor;.\system\delay;.\hardware\temperature;.\hardware\lumination;.\hardware\usart;.\hardware\display_lcd12864;.\hardware\display_lcd1602;.\system\control;.\system\iic;.\system\timer;.\hardware\clock
  group Source Group 1
    ./: STARTUP.A51
    ./hardware/motor/: motordriver.c
    ./hardware/clock/: DS1302.c
    ./hardware/display_lcd1602/: lcd1602.c
